# IAR project coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F750N8 ST STM32F750N8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F750xx; USE_HAL_DRIVER; USE_STM32F7508_DISCO; MBEDTLS_CONFIG_FILE="mbedtls_config.h"; IAR_IDE; __VFP_FP__; __ICCARM__; ITERATIONS=40000; COREMARK
  ICCARM.CCIncludePath2: ..\coremark\inc; ..\..\microej\config\inc; ..\..\microej\core\inc; ..\..\microej\main\inc; ..\..\..\sdk\drivers\BSP\Components\Common; ..\..\..\sdk\drivers\BSP\STM32F7508-Discovery; ..\..\..\sdk\drivers\CMSIS\Core\Include; ..\..\..\sdk\drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\sdk\drivers\CMSIS\Include; ..\..\..\sdk\drivers\STM32F7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\microej\config\inc
  OBJCOPY.OOCOutputFile: coremark.hex
  ILINK.IlinkOutputFile: coremark.out
  ILINK.IlinkIcfFile: STM32F750N8Hx_FLASH.icf
  ILINK.IlinkExtraOptions: --no_range_reservations
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F750xx; USE_HAL_DRIVER; USE_STM32F7508_DISCO; MBEDTLS_CONFIG_FILE="mbedtls_config.h"; IAR_IDE; __VFP_FP__; __ICCARM__; ITERATIONS=40000; COREMARK
  group coremark/inc
    ../coremark/inc/: core_portme.h coremark.h
  group coremark/src
    ../coremark/src/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group microej/config/inc
    ../../microej/config/inc/: ffconf.h FreeRTOSConfig.h lwipopts.h mbedtls_config.h stm32f7xx_hal_conf.h usbh_conf.h watchdog_config.h
  group microej/core/inc
    ../../microej/core/inc/: bsp_util.h cpuload.h cpuload_conf.h cpuload_impl.h device.h fault_handlers.h interrupts.h microej.h microej_main.h microej_time.h
  group microej/core/src
    ../../microej/core/src/: fault_handlers.c putchar.c
  group microej/main/inc
    ../../microej/main/inc/: main.h memory.h memory_msp.h stm32f7xx_it.h
  group microej/main/src
    ../../microej/main/src/: fmc.c main.c memory_msp.c qspi.c stm32f7xx_custom.c stm32f7xx_it.c system_stm32f7xx.c
  group sdk/Drivers/BSP/Components/ft5336
    ../../../sdk/Drivers/BSP/Components/ft5336/: ft5336.c ft5336.h
  group sdk/Drivers/BSP/STM32F7508-Discovery
    ../../../sdk/Drivers/BSP/STM32F7508-Discovery/: stm32f7508_discovery.c stm32f7508_discovery.h stm32f7508_discovery_audio.c stm32f7508_discovery_audio.h stm32f7508_discovery_camera.c stm32f7508_discovery_camera.h stm32f7508_discovery_eeprom.c stm32f7508_discovery_eeprom.h stm32f7508_discovery_lcd.c stm32f7508_discovery_lcd.h stm32f7508_discovery_sd.c stm32f7508_discovery_sd.h stm32f7508_discovery_sdram.c stm32f7508_discovery_sdram.h stm32f7508_discovery_ts.c stm32f7508_discovery_ts.h
  group sdk/Drivers/CMSIS/Core/Include
    ../../../sdk/Drivers/CMSIS/Core/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group sdk/Drivers/CMSIS/Device/ST/STM32F7xx/Include
    ../../../sdk/Drivers/CMSIS/Device/ST/STM32F7xx/Include/: stm32f750xx.h stm32f7xx.h system_stm32f7xx.h
  group sdk/Drivers/CMSIS/Include
    ../../../sdk/Drivers/CMSIS/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group sdk/Drivers/STM32F7xx_HAL_Driver/Inc
    ../../../sdk/Drivers/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.h stm32f7xx_hal_can.h stm32f7xx_hal_cec.h stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.h stm32f7xx_hal_cryp.h stm32f7xx_hal_cryp_ex.h stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dfsdm.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_dsi.h stm32f7xx_hal_eth.h stm32f7xx_hal_exti.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.h stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.h stm32f7xx_hal_irda.h stm32f7xx_hal_irda_ex.h stm32f7xx_hal_iwdg.h stm32f7xx_hal_jpeg.h stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.h stm32f7xx_hal_ltdc_ex.h stm32f7xx_hal_mdios.h stm32f7xx_hal_mmc.h stm32f7xx_hal_nand.h stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rng.h stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sd.h stm32f7xx_hal_sdram.h stm32f7xx_hal_smartcard.h stm32f7xx_hal_smartcard_ex.h stm32f7xx_hal_smbus.h stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.h stm32f7xx_hal_spi_ex.h stm32f7xx_hal_sram.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_wwdg.h stm32f7xx_ll_adc.h stm32f7xx_ll_bus.h stm32f7xx_ll_cortex.h stm32f7xx_ll_crc.h stm32f7xx_ll_dac.h stm32f7xx_ll_dma.h stm32f7xx_ll_dma2d.h stm32f7xx_ll_exti.h stm32f7xx_ll_fmc.h stm32f7xx_ll_gpio.h stm32f7xx_ll_i2c.h stm32f7xx_ll_iwdg.h stm32f7xx_ll_lptim.h stm32f7xx_ll_pwr.h stm32f7xx_ll_rcc.h stm32f7xx_ll_rng.h stm32f7xx_ll_rtc.h stm32f7xx_ll_sdmmc.h stm32f7xx_ll_spi.h stm32f7xx_ll_system.h stm32f7xx_ll_tim.h stm32f7xx_ll_usart.h stm32f7xx_ll_usb.h stm32f7xx_ll_utils.h stm32f7xx_ll_wwdg.h
  group sdk/Drivers/STM32F7xx_HAL_Driver/Src
    ../../../sdk/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
  group startup
    ./: startup_stm32f750xx.s
