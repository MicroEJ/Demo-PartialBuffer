# IAR project iperf.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F750N8 ST STM32F750N8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F750xx; USE_HAL_DRIVER; USE_STM32F7508_DISCO; MBEDTLS_CONFIG_FILE="mbedtls_config.h"; IAR_IDE; __VFP_FP__; __ICCARM__; IPERF
  ICCARM.CCIncludePath2: ..\iperf\inc; ..\..\microej\config\inc; ..\..\microej\core\inc; ..\..\microej\main\inc; ..\..\microej\net\inc; ..\..\microej\thirdparty\systemview\inc; ..\..\microej\thirdparty\systemview-freertos\inc; ..\..\..\sdk\drivers\BSP\Components\Common; ..\..\..\sdk\drivers\BSP\STM32F7508-Discovery; ..\..\..\sdk\drivers\CMSIS\Core\Include; ..\..\..\sdk\drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\sdk\drivers\CMSIS\Include; ..\..\..\sdk\drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\third_party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\third_party\FreeRTOS\Source\include; ..\..\..\third_party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\third_party\LwIP\src\include; ..\..\..\third_party\LwIP\src\include\compat\posix; ..\..\..\third_party\LwIP\system
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\microej\config\inc; ..\..\..\third_party\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: iperf.hex
  ILINK.IlinkOutputFile: iperf.out
  ILINK.IlinkIcfFile: STM32F750N8Hx_FLASH.icf
  ILINK.IlinkExtraOptions: --no_range_reservations
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F750xx; USE_HAL_DRIVER; USE_STM32F7508_DISCO; MBEDTLS_CONFIG_FILE="mbedtls_config.h"; IAR_IDE; __VFP_FP__; __ICCARM__; IPERF
  group iperf/inc
    ../iperf/inc/: iperf.h iperf_configuration.h LLNET_CONF.h sni.h
  group iperf/src
    ../iperf/src/: iperf_main.c LLNET_NETWORK_MEM.c
  group microej/config/inc
    ../../microej/config/inc/: ffconf.h FreeRTOSConfig.h lwipopts.h mbedtls_config.h stm32f7xx_hal_conf.h usbh_conf.h watchdog_config.h
  group microej/core/inc
    ../../microej/core/inc/: bsp_util.h cpuload.h cpuload_conf.h cpuload_impl.h device.h fault_handlers.h interrupts.h microej.h microej_main.h microej_time.h
  group microej/core/src
    ../../microej/core/src/: fault_handlers.c hooks_FreeRTOS.c putchar.c
  group microej/main/inc
    ../../microej/main/inc/: main.h memory.h memory_msp.h stm32f7xx_it.h
  group microej/main/src
    ../../microej/main/src/: fmc.c main.c memory_msp.c qspi.c stm32f7xx_custom.c stm32f7xx_it.c system_stm32f7xx.c
  group microej/net/inc
    ../../microej/net/inc/: async_select.h async_select_cache.h async_select_configuration.h ethernetif.h LLNET_Common.h LLNET_configuration.h LLNET_NETWORK_MEM.h lwip_util.h MicroEJ_errno.h
  group microej/net/inc/sys
    ../../microej/net/inc/sys/: time.h
  group microej/net/src
    ../../microej/net/src/: ethernetif.c lwip_util.c
  group microej/thirdparty/systemview/inc
    ../../microej/thirdparty/systemview/inc/: Global.h SEGGER.h SEGGER_RTT.h SEGGER_RTT_configuration.h SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_configuration.h SEGGER_SYSVIEW_Int.h
  group microej/thirdparty/systemview/src
    ../../microej/thirdparty/systemview/src/: SEGGER_RTT.c SEGGER_SYSVIEW.c
  group microej/thirdparty/systemview-freertos/inc
    ../../microej/thirdparty/systemview-freertos/inc/: SEGGER_SYSVIEW_FreeRTOS.h
  group microej/thirdparty/systemview-freertos/src
    ../../microej/thirdparty/systemview-freertos/src/: SEGGER_SYSVIEW_FreeRTOS.c
  group sdk/Drivers/BSP/Components/ft5336
    ../../../sdk/Drivers/BSP/Components/ft5336/: ft5336.c ft5336.h
  group sdk/Drivers/BSP/STM32F7508-Discovery
    ../../../sdk/Drivers/BSP/STM32F7508-Discovery/: stm32f7508_discovery.c stm32f7508_discovery.h stm32f7508_discovery_audio.c stm32f7508_discovery_audio.h stm32f7508_discovery_camera.c stm32f7508_discovery_camera.h stm32f7508_discovery_eeprom.c stm32f7508_discovery_eeprom.h stm32f7508_discovery_lcd.c stm32f7508_discovery_lcd.h stm32f7508_discovery_sd.c stm32f7508_discovery_sd.h stm32f7508_discovery_sdram.c stm32f7508_discovery_sdram.h stm32f7508_discovery_ts.c stm32f7508_discovery_ts.h
  group sdk/Drivers/CMSIS/Core/Include
    ../../../sdk/Drivers/CMSIS/Core/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group sdk/Drivers/CMSIS/Device/ST/STM32F7xx/Include
    ../../../sdk/Drivers/CMSIS/Device/ST/STM32F7xx/Include/: stm32f750xx.h stm32f7xx.h system_stm32f7xx.h
  group sdk/Drivers/CMSIS/Include
    ../../../sdk/Drivers/CMSIS/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group sdk/Drivers/STM32F7xx_HAL_Driver/Inc
    ../../../sdk/Drivers/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.h stm32f7xx_hal_can.h stm32f7xx_hal_cec.h stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.h stm32f7xx_hal_cryp.h stm32f7xx_hal_cryp_ex.h stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dfsdm.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_dsi.h stm32f7xx_hal_eth.h stm32f7xx_hal_exti.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.h stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.h stm32f7xx_hal_irda.h stm32f7xx_hal_irda_ex.h stm32f7xx_hal_iwdg.h stm32f7xx_hal_jpeg.h stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.h stm32f7xx_hal_ltdc_ex.h stm32f7xx_hal_mdios.h stm32f7xx_hal_mmc.h stm32f7xx_hal_nand.h stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rng.h stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sd.h stm32f7xx_hal_sdram.h stm32f7xx_hal_smartcard.h stm32f7xx_hal_smartcard_ex.h stm32f7xx_hal_smbus.h stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.h stm32f7xx_hal_spi_ex.h stm32f7xx_hal_sram.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_wwdg.h stm32f7xx_ll_adc.h stm32f7xx_ll_bus.h stm32f7xx_ll_cortex.h stm32f7xx_ll_crc.h stm32f7xx_ll_dac.h stm32f7xx_ll_dma.h stm32f7xx_ll_dma2d.h stm32f7xx_ll_exti.h stm32f7xx_ll_fmc.h stm32f7xx_ll_gpio.h stm32f7xx_ll_i2c.h stm32f7xx_ll_iwdg.h stm32f7xx_ll_lptim.h stm32f7xx_ll_pwr.h stm32f7xx_ll_rcc.h stm32f7xx_ll_rng.h stm32f7xx_ll_rtc.h stm32f7xx_ll_sdmmc.h stm32f7xx_ll_spi.h stm32f7xx_ll_system.h stm32f7xx_ll_tim.h stm32f7xx_ll_usart.h stm32f7xx_ll_usb.h stm32f7xx_ll_utils.h stm32f7xx_ll_wwdg.h
  group sdk/Drivers/STM32F7xx_HAL_Driver/Src
    ../../../sdk/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
  group startup
    ./: startup_stm32f750xx.s
  group third_party/FreeRTOS/Source
    ../../../third_party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group third_party/FreeRTOS/Source/CMSIS_RTOS
    ../../../third_party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.h
  group third_party/FreeRTOS/Source/include
    ../../../third_party/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group third_party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1
    ../../../third_party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group third_party/FreeRTOS/Source/portable/MemMang
    ../../../third_party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group third_party/LwIP/src/api
    ../../../third_party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group third_party/LwIP/src/apps/lwiperf
    ../../../third_party/LwIP/src/apps/lwiperf/: lwiperf.c
  group third_party/LwIP/src/core
    ../../../third_party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group third_party/LwIP/src/core/ipv4
    ../../../third_party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group third_party/LwIP/src/core/ipv6
    ../../../third_party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group third_party/LwIP/src/include/compat/posix
    ../../../third_party/LwIP/src/include/compat/posix/: netdb.h
  group third_party/LwIP/src/include/compat/posix/arpa
    ../../../third_party/LwIP/src/include/compat/posix/arpa/: inet.h
  group third_party/LwIP/src/include/compat/posix/net
    ../../../third_party/LwIP/src/include/compat/posix/net/: if.h
  group third_party/LwIP/src/include/compat/posix/sys
    ../../../third_party/LwIP/src/include/compat/posix/sys/: socket.h
  group third_party/LwIP/src/include/compat/stdc
    ../../../third_party/LwIP/src/include/compat/stdc/: errno.h
  group third_party/LwIP/src/include/lwip
    ../../../third_party/LwIP/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group third_party/LwIP/src/include/lwip/apps
    ../../../third_party/LwIP/src/include/lwip/apps/: lwiperf.h
  group third_party/LwIP/src/include/lwip/priv
    ../../../third_party/LwIP/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group third_party/LwIP/src/include/lwip/prot
    ../../../third_party/LwIP/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group third_party/LwIP/src/include/netif
    ../../../third_party/LwIP/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group third_party/LwIP/src/netif
    ../../../third_party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group third_party/LwIP/system/arch
    ../../../third_party/LwIP/system/arch/: bpstruct.h cc.h cpu.h epstruct.h init.h lib.h perf.h sys_arch.h
  group third_party/LwIP/system/OS
    ../../../third_party/LwIP/system/OS/: sys_arch.c
